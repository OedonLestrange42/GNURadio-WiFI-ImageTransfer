options:
  parameters:
    author: oedon
    generate_options: qt_gui
    id: IRS_AP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''915M'', ''  1 | 3100.0 | 11g'', ''  2 | 2600.0 | 11g'', ''  3 | 4100.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[915000000.0, 3100000000.0, 2600000000.0, 4100000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '915000000.0'
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '910000000'
    step: '1000000'
    stop: '3100000000'
    value: '2500000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["1 MHz", "2 MHz","3MHz", "5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[1e6,2e6,3e6, 5e6, 10e6, 20e6]'
    type: real
    value: 1e6
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: 0.5e6
    step: 0.1e6
    stop: 2e6
    value: 1e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '52'
    type: complex
  states: {state: disabled}
- name: channels_iqbal_gen_0
  id: channels_iqbal_gen
  parameters:
    mag: '2'
    mode: '1'
    phase: '2'
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.05'
    msg_nsamples: '1000'
    type: '0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    AP_pos: '[0.24, 0.24, 0.5]'
    IRS_pos: '[0.015, 0.015, 0]'
    IRS_scale: '16'
    IRS_unit_interval: '0.03'
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport sys\nsys.path.append('/home/oedon/grEnv/lib/python3.11/site-packages/')\nsys.path.append('/home/oedon/桌面/IRS-gnu/')\nimport numpy as np\nimport time\nfrom stable_baselines3 import DQN\nfrom numpy import pi\nfrom typing import List\nfrom gnuradio import gr\nimport socket\nimport matplotlib.pyplot as plt\n\ndef custom_lr_schedule(current_step: int) -> float:\n    pass\n\ndef custom_exploration_schedule(current_step: int) -> float:\n    pass\n\ndef genPhase_nograd(interval, IRS_scale, IRS_pos, AP_pos, theta, phi, cluster_scale=1, freq=5e9):\n    group_scale = IRS_scale // cluster_scale\n\n    Y = np.reshape(np.array([list(range(group_scale)) * group_scale]),\n                        [group_scale, group_scale])\n    X = np.transpose(Y)\n\n    pos = [  # [x0,y0,z0] is the matrix of each IRS unit's position\n        (np.ones((group_scale, group_scale)) * IRS_pos[0] + X * interval),  # x0\n        (np.ones((group_scale, group_scale)) * IRS_pos[1] + Y * interval),  # y0\n        (np.ones((group_scale, group_scale)) * IRS_pos[2])]\n    # radians rather than degree!\n    k = 2 * pi * freq / 3e8\n    atpos = [  # [x1,y1,z1] is the matrix of AP's position\n        (np.ones((IRS_scale, IRS_scale)) * AP_pos[0]),  # x1\n        (np.ones((IRS_scale, IRS_scale)) * AP_pos[1]),  # y1\n        (np.ones((IRS_scale, IRS_scale)) * AP_pos[2])]  # z1\n\n    D = np.power(np.power((pos[0] - atpos[0]), 2) + \\\n                 np.power((pos[1] - atpos[1]), 2) + \\\n                 np.power((pos[2] - atpos[2]), 2), 0.5)\n    if not theta == 0:\n        D1 = np.sin(theta) * np.cos(phi) * pos[1]\n        D2 = np.sin(theta) * np.sin(phi) * pos[0]\n        pha = k * (D - D1 - D2)\n    else:\n        D1 = np.sin(phi) * np.cos(theta) * pos[0]\n        D2 = np.sin(phi) * 0 * pos[1]\n        pha = k * (D - D1 - D2)\n\n    return np.exp(1j * pha)\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self,\n                 vectorSize:int=1,\n                 IRS_unit_interval:float=0.03,\n                 IRS_scale:int=16,\n                 IRS_pos:List=[0.015, 0.015, 0],\n                 AP_pos:List=[0.24, 0.24, 0.5],\n                 visualize:bool=False):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='IRS control block',   # will show up in GRC\n            in_sig=[(np.complex64, vectorSize)],\n            out_sig=None\n        )\n        # bluetooth server\n        self.s = socket.socket(socket.AF_INET, socket.SOCK_STREAM)\n        self.s.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)  # reboot socket\n        self.host = '192.168.10.5'\n        self.port = 56666\n        self.s.bind((self.host, self.port))  # bind\n        self.s.setblocking(False)\n        self.s.listen(5)\n        # static params\n        self.IRS_unit_interval = IRS_unit_interval\n        self.IRS_scale = IRS_scale\n        self.N = IRS_scale**2\n        # self.model = DQN.load('/home/oedon/桌面/IRS-gnu/ppo_sub-channel_SB3')\n        self.model = DQN.load('/home/oedon/桌面/IRS-gnu/ppo_sub-channel_SB3.zip', custom_objects={\"lr_schedule\": custom_lr_schedule, \"exploration_schedule\": custom_exploration_schedule})\n        \n        # initialize\n        self.Psi = genPhase_nograd(self.IRS_unit_interval, self.IRS_scale, IRS_pos, AP_pos, 0, 0)\n        \n        # action set\n        self.ShiftArray1 = [np.exp(1j * pi * 1 * np.arange(0, self.N, 1) / self.N),\n                            np.exp(-1j * pi * 1 * np.arange(0, self.N, 1) / self.N),\n                            np.exp(1j * pi * 2 * np.arange(0, self.N, 1) / self.N),\n                            np.exp(-1j * pi * 2 * np.arange(0, self.N, 1) / self.N),\n                            np.exp(4j * pi * 2 * np.arange(0, self.N, 1) / self.N),\n                            np.exp(-4j * pi * 2 * np.arange(0, self.N, 1) / self.N),\n                            np.exp(0j * pi * 2 * np.arange(0, self.N, 1) / self.N)]\n        tmp = [np.transpose(np.reshape(a, (self.IRS_scale, self.IRS_scale))).flatten() for a in self.ShiftArray1[:-1]]\n        self.ShiftArray1.extend(tmp)\n\n        # visualize\n        self.visualize = visualize\n        if visualize:\n            plt.figure()\n            plt.ion()\n\n    def work(self, input_items, output_items):\n        # print(self.host)\n        H = np.sum(np.array(input_items))\n        H = np.ones(258) * H\n        CSI = np.hstack([H.real.flatten(), H.imag.flatten()])\n        IRS = np.vstack([self.Psi.real.flatten().astype(int), self.Psi.imag.flatten().astype(int)])\n        obs = {\"CSI\": CSI, \"IRS\": IRS}\n        a = self.step(obs)\n        if self.visualize:\n            p_real = np.where(np.angle(self.Psi) > 0, 1, 0)\n            plt.clf()\n            plt.imshow(p_real, cmap='jet', interpolation='nearest')\n            plt.title('Current IRS pattern')\n        return len(a)\n\n    def step(self, obs):\n        # print('predicting...')\n        action, _ = self.model.predict(obs, deterministic=True)\n        action = action.item()\n        try:\n            conn, addr = self.s.accept()\n            conn.send(action.to_bytes(4,byteorder='little'))\n            print('send!')\n            self.Psi *= np.reshape(self.ShiftArray1[action], (self.IRS_scale, self.IRS_scale))  # only send seccessfully\n            time.sleep(0.1)\n            conn.close()\n        except BlockingIOError:\n            pass\n        return [action]\n\n        \n\n"
    vectorSize: '1'
    visualize: 'False'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import pdb\n\nimport pmt\nimport socket\nimport numpy as np\nimport pickle\nfrom gnuradio import gr\nfrom PIL import Image\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    def __init__(self,\n                 image_hight: int = 240,\n                 image_width: int = 240):  # only default arguments here\n        gr.basic_block.__init__(\n            self,\n            name='Extract Pics',  # will be shown in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        self.message_port_register_in(pmt.intern('MAC'))\n        self.set_msg_handler(pmt.intern('MAC'), self.handle_msg)\n        self.skt = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)\n        self.H = image_hight\n        self.W = image_width\n\n    def handle_msg(self, msg):\n        # This is where you handle the message. You can access the data using pmt.to_python(msg).\n        # global patch_list\n        try:\n            data = pmt.to_python(msg)[-1]\n            # print(len(data))\n            # pdb.set_trace()\n            target = data[24:]  # loaded data\n            pics = target[4:]\n            img = bytes(pics)\n            # img = pickle.dumps(pics)\n            self.skt.sendto(img, ('localhost', 10010))\n        except UnicodeDecodeError as e:\n            print(f\"An error occurred: {e}\")\n            # pass\n        # print(f'msg received, current msg list length {len(patch_list)}')\n\n"
    image_hight: '300'
    image_width: '300'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_extract_csi_0
  id: ieee802_11_extract_csi
  parameters: {}
  states: {state: disabled}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Rx signal"'
    size: 48*10
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"CSI"'
    size: 48*10
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"Rx signal"'
    size: 48*10
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    dev_args: '''hackrf=0'''
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: '500000'
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: WiFi Sync Short cor
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: WiFi Sync Short in
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: WiFi Sync Short abs
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: demoded
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: WiFi Sync Short in
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: WiFi Sync Short abs
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: WiFi Sync Short cor
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: demoded
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', virtual_sink_0_0, '0']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_divide_xx_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', qtgui_sink_x_0, '0']
- [blocks_moving_average_xx_1, '0', virtual_sink_0_1, '0']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0_0, '0', epy_block_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [channels_iqbal_gen_0, '0', blocks_complex_to_mag_squared_0, '0']
- [channels_iqbal_gen_0, '0', blocks_delay_0_0, '0']
- [channels_iqbal_gen_0, '0', blocks_multiply_xx_0, '0']
- [digital_probe_mpsk_snr_est_c_0, snr, blocks_message_debug_0, print]
- [fft_vxx_0, '0', virtual_sink_1, '0']
- [ieee802_11_decode_mac_0, out, epy_block_2, MAC]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_extract_csi_0, '0', blocks_vector_to_stream_0_0, '0']
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_parse_mac_0, out, ieee802_11_extract_csi_0, pdu in]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_long_0, '0', qtgui_const_sink_x_0_1, '0']
- [ieee802_11_sync_short_0_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0_0, '0', ieee802_11_sync_long_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [soapy_hackrf_source_0, '0', blocks_delay_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', channels_iqbal_gen_0, '0']
- [virtual_source_0, '0', ieee802_11_sync_short_0_0, '0']
- [virtual_source_0_1, '0', ieee802_11_sync_short_0_0, '1']
- [virtual_source_0_2, '0', ieee802_11_sync_short_0_0, '2']
- [virtual_source_1, '0', ieee802_11_frame_equalizer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
