options:
  parameters:
    author: oedon
    generate_options: qt_gui
    id: IRS_user
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '4'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''915M'', ''  1 | 4100.0 | 11g'',''  2 | 2472.0 | 11g'', ''  3 | 3100.0 | 11g'', ''  4 | 2600.0 | 11g'', ''  5 | 2880.0 | 11g'', ''  6 | 3020.0 | 11g'', ''  7 | 3160.0 | 11g'', ''  8 | 3300.0 | 11g'', ''  9 | 3440.0 | 11g'', ''  10 | 3580.0 | 11g'', ''  11 | 3720.0 | 11g'', ''  12 | 3860.0 | 11g'']'
    num_opts: '0'
    options: |-
      [915000000.0, 4.10e+09, 2.472e+09, 3.10e+09, 2.60e+09, 2.88e+09, 3.02e+09,
             3.16e+09, 3.30e+09, 3.44e+09, 3.58e+09, 3.72e+09, 3.86e+09]
    type: real
    value: '915000000.0'
  states: {state: disabled}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '910000000'
    step: '1000000'
    stop: '3100000000'
    value: '2500000000'
  states: {}
- name: interval
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '2'
    step: '1'
    stop: '1500'
    value: '5'
  states: {}
- name: multi_const
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.05'
    stop: '0.6'
    value: '0.1'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: pdu_length
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '10'
    step: '1'
    stop: '500'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["1 MHz", "5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[1e6, 5e6, 10e6, 20e6]'
    type: real
    value: 1e6
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("x".join('y' for i in range(pdu_length)))
    period: interval
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: multi_const
    minoutbuf: '100000'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: (0,)
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.01'
    minoutbuf: out_buf_size
    pad_front: '100'
    pad_tail: '1000'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 255]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '65507'
    port: '50010'
    type: UDP_SERVER
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate *2
    fc: freq
    fftsize: '2048'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate/2
    center_freq0: freq
    dev_addr: '"usrp=0"'
    gain0: '15'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: wifi_phy_hier_0_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: ieee802_11.LS
    encoding: ieee802_11.Encoding(encoding)
    frequency: freq
    sensitivity: '0.56'
  states: {}

connections:
- [blocks_message_strobe_0_0, strobe, ieee802_11_mac_0, app in]
- [blocks_multiply_const_vxx_0, '0', foo_packet_pad2_0, '0']
- [blocks_vector_source_x_0, '0', wifi_phy_hier_0_0, '0']
- [foo_packet_pad2_0, '0', qtgui_sink_x_0, '0']
- [foo_packet_pad2_0, '0', soapy_hackrf_sink_0, '0']
- [foo_packet_pad2_0, '0', uhd_usrp_sink_0, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0_0, mac_in]
- [network_socket_pdu_0, pdus, ieee802_11_mac_0, app in]
- [wifi_phy_hier_0_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
